CMDLINE:append = " loglevel=4"
