VOLATILE_BINDS = "\
    /mnt/state/lib /var/lib\n\
    /mnt/state/cache /var/cache\n\
    /mnt/state/spool /var/spool\n\
    /mnt/state/srv /srv\n\
"
